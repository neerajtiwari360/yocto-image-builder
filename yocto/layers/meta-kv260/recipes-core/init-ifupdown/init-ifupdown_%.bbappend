# Override the default DHCP configuration only for this offline KV260 machine.
FILESEXTRAPATHS:prepend:kv260-base := "${THISDIR}/files:"
