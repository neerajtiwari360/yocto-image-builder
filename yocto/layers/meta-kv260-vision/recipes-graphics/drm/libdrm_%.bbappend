# KMS ioctl wrapper only: no unrelated GPU drivers, demos or graphics stack.
PACKAGECONFIG:kv260-vision = ""
